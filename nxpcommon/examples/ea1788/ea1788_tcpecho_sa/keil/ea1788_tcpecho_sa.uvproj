# Keil uVision project ea1788_tcpecho_sa.uvproj, settings and files
target DRAM_ZC (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ea1788_tcpecho_sa +hex
  c flags: Optim=4 wLevel=1
  c include: ..\source;..\..\..\..\arch;..\..\..\..\board;..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\nxpcommon;..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\BoardSupport;..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\dram_zc;..\..\..\..\arch\lpc177x_8x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\DRAM\DRAM_ZC.sct
  group Startup
    C:/dev/git/lwip_work/updated/lpc177x_8x/lwip_lpc/nxpcommon/examples/ea1788/ea1788_common/keil/: startup_LPC177x_8x.s
    ../../../../../../BoardSupport/: sdram_is42s32800d.c
  group CMSIS-CM3
    ../../../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../../../Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_systick.c lpc177x_8x_uart.c lpc177x_8x_emc.c lpc177x_8x_timer.c
  group Application
    ../../../../: lpc_phy.c
    ../../../../arch/: lpc_debug.c sys_arch.c
    ../../../../arch/lpc177x_8x/keil/: Retarget.c
    ../../../../arch/lpc177x_8x/: lpc17_emac.c lpc17_emac_zcbuffs.c lpc177x_8x_systick_arch.c Serial.c
    ../../../../board/ea1788/: ea1788_board.c
    ../source/: tcpecho_sa_app.c
    ../../../../../contrib-1.4.0/apps/tcpecho_raw/: echo.c
  group lwip
    ../../../../../lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../lwip-1.4.0/src/netif/: etharp.c
target FLASH_ZC (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: ea1788_tcpecho_sa +hex
  c flags: Optim=4 wLevel=1
  c include: ..\source;..\..\..\..\arch;..\..\..\..\board;..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\nxpcommon;..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\BoardSupport;..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\flash_zc;..\..\..\..\arch\lpc177x_8x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Flash\Flash_ZC.sct
target FLASH_CP (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: ea1788_tcpecho_sa +hex
  c flags: Optim=4 wLevel=1
  c include: ..\source;..\..\..\..\arch;..\..\..\..\board;..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\nxpcommon;..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\BoardSupport;..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\flash_cp;..\..\..\..\arch\lpc177x_8x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Flash\Flash_CP.sct
target IRAM_CP (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: ea1788_tcpecho_sa +hex
  c flags: Optim=4 wLevel=1
  c define: __RAM_MODE__
  c include: ..\source;..\..\..\..\arch;..\..\..\..\board;..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\nxpcommon;..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\BoardSupport;..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\iram_cp;..\..\..\..\arch\lpc177x_8x
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\IRAM\IRAM_CP.sct
target IRAM_ZC (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: ea1788_tcpecho_sa +hex
  c flags: Optim=4 wLevel=1
  c define: __RAM_MODE__
  c include: ..\source;..\..\..\..\arch;..\..\..\..\board;..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include;..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\nxpcommon;..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\BoardSupport;..\..\..\..\..\contrib-1.4.0\apps\tcpecho_raw;..\source\configs\iram_zc;..\..\..\..\arch\lpc177x_8x
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\IRAM\IRAM_ZC.sct
