# IAR project ea1788_httpraw_sa.ewp, settings and files
configuration flash_zc (ARM)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\source; ..\..\..\..\..\arch; ..\..\..\..\..\..\..\Drivers\include; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\..\..\lwip-1.4.0\src\include; ..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\nxpcommon; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\BoardSupport; ..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw; ..\source\configs\flash_zc; ..\..\..\..\..\..\nxpcommon\arch\lpc177x_8x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ea1788_httpraw_sa.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\dev\git\lwip_work\updated\lpc177x_8x\lwip_lpc\nxpcommon\examples\ea1788\ea1788_httpraw_sa\iar\configs\flash_zc_ea1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_cp (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\source; ..\..\..\..\..\arch; ..\..\..\..\..\..\..\Drivers\include; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\..\..\lwip-1.4.0\src\include; ..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\nxpcommon; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\BoardSupport; ..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw; ..\source\configs\flash_cp; ..\..\..\..\..\..\nxpcommon\arch\lpc177x_8x
  ILINK.IlinkIcfFile: C:\dev\git\lwip_work\updated\lpc177x_8x\lwip_lpc\nxpcommon\examples\ea1788\ea1788_httpraw_sa\iar\configs\flash_cp_ea1788.icf
configuration dram_zc (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\source; ..\..\..\..\..\arch; ..\..\..\..\..\board; ..\..\..\..\..\..\..\Drivers\include; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\Include; ..\..\..\..\..\..\lwip-1.4.0\src\include; ..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4; ..\..\..\..\..\..\nxpcommon; ..\..\..\..\..\..\..\Core\Device\NXP\LPC177x_8x\BoardSupport; ..\..\..\..\..\..\contrib-1.4.0\apps\httpserver_raw; ..\source\configs\dram_zc; ..\..\..\..\..\..\nxpcommon\arch\lpc177x_8x
  ILINK.IlinkIcfFile: C:\dev\git\lwip_work\updated\lpc177x_8x\lwip_lpc\nxpcommon\examples\ea1788\ea1788_httpraw_sa\iar\configs\dram_zc_ea1788.icf
  group Application
    ../../ea1788_common/: ea1788_board.c
    ../../../../../../contrib-1.4.0/apps/httpserver_raw/: fs.c httpd.c
    ../source/: httpraw_sa_app.c
    ../../../../../arch/lpc177x_8x/: lpc177x_8x_systick_arch.c lpc17_emac.c lpc17_emac_zcbuffs.c
    ../../../../../arch/: lpc_debug.c Retarget.c sys_arch.c
    ../../../../../: lpc_phy_lan8720.c
  group CMSIS-CM3
    ../../../../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emc.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c
  group lwip
    ../../../../../../lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../lwip-1.4.0/src/netif/: etharp.c
  group Startup
    ../../../../../../../BoardSupport/: sdram_is42s32800d.c
    ../../ea1788_common/IAR/: startup_LPC177x_8x.s
