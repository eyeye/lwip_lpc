# Keil uVision project hitex4350_tcpecho_freertos.uvproj, settings and files
target IRAM (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: hitex4350_tcpecho_freertos +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M4 LPC43XX
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\Drivers\include;..\..\..\..\..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\tcpecho;..\source\configs\iram;..\..\..\..\..\..\arch\lpc18xx_43xx;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\include;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  scatter file: .\IRAM\IRAM.sct
  group Startup
    ../../../../../../../../Core/Device/NXP/LPC43xx/Source/: fpu_init.c fpu_enable.c
    ../../../../../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../../../lpc43xx_common/keil/: startup_LPC43xx_freertos.s
  group Drivers
    ../../../../../../../../Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_uart.c
  group Application
    C:/dev/git/lwip_work/lpc43xx/lwip_lpc/nxpcommon/arch/: lpc_debug.c sys_arch.c Retarget.c
    ../source/: tcpecho_freertos_app.c
    ../../../../../../../contrib-1.4.0/apps/tcpecho/: tcpecho.c
    ../../../../../../arch/lpc18xx_43xx/: lpc18xx_43xx_emac.c
    ../../hitex4350_common/: hitex4350_board.c
    ../../../../lpc18xx_43xx_common/: lpc4350_freertos_hooks.c
    ../../../../../../: lpc_phy_dp83848.c
  group lwip
    C:/dev/git/lwip_work/lpc43xx/lwip_lpc/lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    C:/dev/git/lwip_work/lpc43xx/lwip_lpc/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    C:/dev/git/lwip_work/lpc43xx/lwip_lpc/lwip-1.4.0/src/netif/: etharp.c
    C:/dev/git/lwip_work/lpc43xx/lwip_lpc/lwip-1.4.0/src/api/: tcpip.c netifapi.c netbuf.c api_msg.c api_lib.c
  group freertos
    C:/dev/git/lwip_work/lpc43xx/FreeRTOSV7.1.0/Source/: tasks.c queue.c list.c
    C:/dev/git/lwip_work/lpc43xx/FreeRTOSV7.1.0/Source/portable/MemMang/: heap_3.c
    C:/dev/git/lwip_work/lpc43xx/FreeRTOSV7.1.0/Source/portable/RVDS/ARM_CM4F/: port.c
