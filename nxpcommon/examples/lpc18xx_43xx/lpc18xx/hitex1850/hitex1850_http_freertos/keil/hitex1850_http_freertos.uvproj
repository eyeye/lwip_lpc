# Keil uVision project hitex1850_http_freertos.uvproj, settings and files
target IRAM (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M3 LPC18XX
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\lpc18xx\Drivers\include;..\..\..\..\..\..\..\..\lpc18xx\Core\Device\NXP\LPC18xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\lpc18xx\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\httpserver;..\source\configs\iram;..\..\..\..\..\..\arch\lpc18xx_43xx;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\include;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\portable\RVDS\ARM_CM3
  asm define: USE_FREERTOS NO_CRP
  library: MicroLIB
  scatter file: ..\..\hitex1850_common\keil\configs\IRAM.sct
  group Startup
    ../../hitex1850_common/keil/: startup_hitex1850_M3.s
    ../../../../../../../../lpc18xx/Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../../../../../../../lpc18xx/Drivers/source/: debug_frmwrk.c lpc18xx_cgu.c lpc18xx_gpio.c lpc18xx_scu.c lpc18xx_uart.c lpc18xx_emc.c
  group Application
    ../../../../../../../nxpcommon/arch/: lpc_debug.c sys_arch.c Retarget.c
    ../../../../../../arch/lpc18xx_43xx/: lpc18xx_43xx_emac.c
    ../../../../lpc18xx_43xx_common/: lpc18xx_43xx_freertos_hooks.c
    ../../../../../../: lpc_phy_dp83848.c
    ../../../../../../../contrib-1.4.0/apps/httpserver/: httpserver-netconn.c
    ../../hitex1850_common/: hitex1850_board.c
    ../source/: hitex1850_http_freertos.c
  group lwip
    ../../../../../../../lwip-1.4.0/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../../lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../../lwip-1.4.0/src/netif/: etharp.c
    ../../../../../../../lwip-1.4.0/src/api/: tcpip.c netifapi.c netbuf.c api_msg.c api_lib.c
  group freertos
    ../../../../../../../../FreeRTOSV7.1.0/Source/: tasks.c queue.c list.c
    ../../../../../../../../FreeRTOSV7.1.0/Source/portable/MemMang/: heap_3.c
    ../../../../../../../../FreeRTOSV7.1.0/Source/portable/RVDS/ARM_CM3/: port.c
target flash (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: example +hex
  c flags: Optim=4 wLevel=1
  c define: CORE_M3 LPC18XX LWIP_DEBUG
  c include: ..\source;..\..\..\..\..\..\arch;..\..\..\..\..\..\..\..\lpc18xx\Drivers\include;..\..\..\..\..\..\..\..\lpc18xx\Core\Device\NXP\lpc18xx\Include;..\..\..\..\..\..\..\lwip-1.4.0\src\include;..\..\..\..\..\..\..\nxpcommon;..\..\..\..\..\..\..\lwip-1.4.0\src\include\ipv4;..\..\..\..\..\..\..\..\lpc18xx\BoardSupport;..\..\..\..\..\..\..\contrib-1.4.0\apps\httpserver;..\source\configs\flash;..\..\..\..\..\..\arch\lpc18xx_43xx;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\include;..\..\..\..\..\..\..\..\FreeRTOSV7.1.0\Source\portable\RVDS\ARM_CM3
  asm define: USE_FREERTOS NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: ..\..\hitex1850_common\keil\configs\flash.sct
